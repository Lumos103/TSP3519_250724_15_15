# IAR project empty_mspm0g3519_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSPM0G3519 TexasInstruments MSPM0G3519
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __MSPM0G3519__; MOTION_DRIVER_TARGET_MSPM0; MPU6050
  ICCARM.IExtraOptions: --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; $MSPM0_SDK_INSTALL_DIR$/source/third_party/CMSIS/Core/Include; $MSPM0_SDK_INSTALL_DIR$/source; ..\NUEDC2025; ..\TSP3519
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: $PROJ_DIR$; ..\TSP3519; ..\NUEDC2025
  OBJCOPY.OOCOutputFile: empty_mspm0g3519_nortos_iar.srec
  ILINK.IlinkOutputFile: empty_mspm0g3519_nortos_iar.out
  ILINK.IlinkIcfFile: mspm0g3519.icf
  ILINK.IlinkExtraOptions: $MSPM0_SDK_INSTALL_DIR$/source/ti/driverlib/lib/iar/m0p/mspm0gx51x/driverlib.a; --silent
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: SysConfig_Generated_Files.ipcf
  group empty_mspm0g3519
    ./: empty_mspm0g3519.c empty_mspm0g3519.syscfg mspm0g3519.icf README.md
  group empty_mspm0g3519/iar
    iar/: startup_mspm0g351x_iar.c
  group NUEDU2025
    ../NUEDC2025/: tsp_isr.c tsp_isr.h
  group SysConfig Generated Files
    ./: Event.dot ti_msp_dl_config.c ti_msp_dl_config.h
  group TSP3519
    ../TSP3519/: clock.c clock.h dmpKey.h dmpmap.h interrupt.c interrupt.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h mpu6050.c mpu6050.h mspm0_i2c.c mspm0_i2c.h TSP_Encoder.c TSP_Encoder.h tsp_gpio.c tsp_gpio.h TSP_MOTOR.c TSP_MOTOR.h TSP_TFT18.c TSP_TFT18.h
